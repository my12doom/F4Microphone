# Keil uVision project F4Microphone.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MIC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=24000000,USE_USB_OTG_FS
  c include: .\Libraries\STM32_USB_OTG_Driver\inc;.\Libraries\STM32_USB_Device_Library\Class\audio\inc;.\Libraries\STM32_USB_Device_Library\Core\inc;.\src;.\Libraries\STMLib\STM32F4xx_StdPeriph_Driver;.\Utilities\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS&std
    ./Libraries/STMLib/STM32F4xx_StdPeriph_Driver/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group USB
    ./Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./src/: usb_bsp.c
  group main
    ./src/: stm32f4xx_it.c F4GPIO.cpp F4SysTimer.cpp I2C_SW.cpp i2s.cpp main.cpp SWO.cpp SEGGER_RTT.c
  group start
    ./Libraries/STMLib/: system_stm32f401.c startup_stm32f401.s
  group USBD
    ./Libraries/STM32_USB_Device_Library/Class/audio/src/: usbd_audio_core.c
    ./src/: usbd_desc.c usbd_usr.c
  group ADAU1761
    ./src/adau1761/: adau1761_mic_IC_1.cpp
